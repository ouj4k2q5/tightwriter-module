## boards/shields/tightwriter/Kconfig.defconfig
```kconfig
if SHIELD_TIGHTWRITER

config ZMK_KEYBOARD_NAME
    default "Tightwriter"

endif
```
